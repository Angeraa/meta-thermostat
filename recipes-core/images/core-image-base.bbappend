IMAGE_INSTALL:append = " libgpiod-tools libdrm mesa libinput thermostat"
TOOLCHAIN_TARGET_TASK:append = " libgpiod-dev boost-dev"
SDKIMAGE_FEATURES:append = " dev-pkgs"